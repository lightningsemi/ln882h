# Keil uVision project firmware_XIP.uvprojx, settings and files
target firmware_ln882h (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IROM(0x00000000,0x00040000) IRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: firmware_XIP
  BeforeMake: python    ..\..\..\tools\python_scripts\sdk_env_check.py
  BeforeMake: python3 ..\..\..\tools\python_scripts\before_build_keil.py  -p  ..\cfg\flash_partition_cfg.json -o  ..\cfg\flash_partition_table.h
  AfterMake: python3  ..\..\..\tools\python_scripts\after_build_keil.py  -k   #P   -o flashimage.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: LN882H,ARM_MATH_CM4
  c misc: --gnu
  c include: ..\..\..\components;..\..\..\components\ble\app;..\..\..\components\ble\ble_api\common;..\..\..\components\ble\ble_api\gap_gatt\api;..\..\..\components\ble\ble_lib_import;..\..\..\components\ble\mac\ble\hl\api;..\..\..\components\ble\mac\ble\hl\inc;..\..\..\components\ble\mac\ble\ll\api;..\..\..\components\ble\mac\ble\ll\import;..\..\..\components\ble\mac\ble\ll\src;..\..\..\components\ble\mac\ble\ll\src\llm;..\..\..\components\ble\mac\ble\profiles\netcfg\api;..\..\..\components\ble\mac\em\api;..\..\..\components\ble\mac\hci\api;..\..\..\components\ble\mac\sch\api;..\..\..\components\ble\mac\sch\import;..\..\..\components\ble\modules\aes\api;..\..\..\components\ble\modules\common\api;..\..\..\components\ble\modules\dbg\api;..\..\..\components\ble\modules\ecc_p256\api;..\..\..\components\ble\modules\h4tl\api;..\..\..\components\ble\modules\ke\api;..\..\..\components\ble\modules\lib_ver\api;..\..\..\components\ble\modules\nvds\api;..\..\..\components\ble\modules\rf\api;..\..\..\components\ble\modules\rwip\api;..\..\..\components\fs\kv\kv;..\..\..\components\fs\kv\kv_port;..\..\..\components\fs\nvds;..\..\..\components\fs\partition_mgr;..\..\..\components\kernel;..\..\..\components\kernel\FreeRTOS\Source\include;..\..\..\components\kernel\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\..\components\kernel\FreeRTOS_Adapter;..\..\..\components\serial;..\..\..\components\utils;..\..\..\components\utils\debug;..\..\..\mcu\CMSIS_5.3.0;..\..\..\mcu\driver_ln882h;..\..\..\mcu\driver_ln882h\reg;..\..\..\mcu\ln882h;..\app;..\app\app_callback;..\bsp;..\cfg;..\..\..\components\ble\ble_profiles\bas\basc\api;..\..\..\components\ble\ble_profiles\bas\bass\api;..\..\..\components\ble\ble_profiles\dis\disc\api;..\..\..\components\ble\ble_profiles\dis\diss\api;..\..\..\components\ble\ble_profiles\hid\device\api;..\..\..\components\ble\ble_profiles\bas\basc\src;..\..\..\components\ble\ble_profiles\bas\bass\src;..\..\..\components\ble\ble_profiles\dis\disc\src;..\..\..\components\ble\ble_profiles\dis\diss\src;..\..\..\components\ble\ble_profiles\hid\device\src;..\..\..\components\ble\ble_profiles\hid;..\..\..\components\ble\mac\ble\hl\inc;..\..\..\components\ble\ble_api\profiles\bas;..\..\..\components\ble\ble_profiles\prf_common;..\..\..\components\ble;..\..\..\components\ble\ble_arch;..\..\..\components\ble\ble_api\profiles\dis;..\..\..\components\ble\ble_api\profiles\hid
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\cfg\ln882h.sct
  link misc: --keep=*.o(.no_init_data)
  group cpu
    ../startup/: startup_ln882h.S
    ../../../mcu/ln882h/: system_ln882h.c ln882h.h ln882h_rom_fun.h mem_map_ln882h.h base_addr_ln882h.h
  group ln882h_hal
    ../../../mcu/driver_ln882h/hal/: hal_cache.c hal_common.c hal_flash.c hal_qspi.c hal_uart.c hal_wdt.c hal_trng.c hal_gpio.c hal_interrupt.c hal_clock.c hal_misc.c hal_ext.c hal_timer.c hal_adc.c hal_efuse.c
  group main_entry
    ../app/: main.c usr_app.c
  group bsp
    ../bsp/: serial_hw.c
  group util
    ../../../components/utils/debug/: ln_assert.c log.c
    ../../../components/utils/fifo/: fifobuf.c
    ../../../components/utils/: crc32.c wrap_stdio.c ln_misc.c
    ../../../components/utils/debug/CmBacktrace/: cm_backtrace.c
    ../../../components/utils/reboot_trace/: reboot_trace.c
    ../../../components/utils/runtime/: runtime.c
  group FreeRTOS
    ../../../components/kernel/FreeRTOS/Source/: event_groups.c list.c queue.c tasks.c timers.c
    ../../../components/kernel/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../../components/kernel/FreeRTOS/: hooks.c
    ../../../components/kernel/FreeRTOS/Source/portable/MemMang/: heap_5.c
  group FreeRTOS_Adapter
    ../../../components/kernel/FreeRTOS_Adapter/: freertos_debug.c freertos_mutex.c freertos_queue.c freertos_semaphore.c freertos_thread.c freertos_timer.c freertos_common.c freertos_cpuusage.c
    ../../../components/kernel/osal/: osal.h
  group serial
    ../../../components/serial/: serial.c
  group lib
    ../../../lib/armcclib/: arm_cortexM4lf_math.lib ln882h_ble_full_stack.lib
  group fs
    ../../../components/fs/partition_mgr/: flash_partition_mgr.c
    ../../../components/fs/nvds/: ln_nvds.c
    ../../../components/fs/kv/kv/: ln_kv.c
    ../../../components/fs/kv/kv_port/: ln_kv_port.c
  group ble_port
    ../../../components/ble/ble_arch/: ble_arch_main.c
    ../../../components/ble/ble_lib_import/: ble_port.c ble_port.h
  group ble_profile
    ../../../components/ble/ble_profiles/bas/basc/src/: basc.c basc_task.c
    ../../../components/ble/ble_profiles/bas/bass/src/: bass.c bass_task.c
    ../../../components/ble/ble_profiles/dis/disc/src/: disc.c disc_task.c
    ../../../components/ble/ble_profiles/dis/diss/src/: diss.c diss_task.c
    ../../../components/ble/ble_profiles/hid/device/src/: hogpd.c hogpd_task.c
    ../../../components/ble/ble_profiles/hid/report_host/src/: hogprh.c hogprh_task.c
    ../../../components/ble/ble_profiles/prf_common/: prf_utils.c prf_ble.c
  group ble_app
    ../app/app_callback/: ln_app_callback.c ln_gap_callback.c ln_gatt_callback.c ln_bas_callback.c usr_ble_app.c ln_dis_callback.c ln_hid_callback.c
  group ble_api
    ../../../components/ble/ble_api/gap_gatt/src/: ln_app_gap.c ln_app_gatt.c
    ../../../components/ble/ble_api/profiles/bas/: ln_app_bas.c
    ../../../components/ble/ble_api/profiles/dis/: ln_app_dis.c
    ../../../components/ble/ble_api/profiles/hid/: ln_app_hid.c
