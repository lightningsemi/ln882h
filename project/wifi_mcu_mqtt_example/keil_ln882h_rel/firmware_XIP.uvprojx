# Keil uVision project firmware_XIP.uvprojx, settings and files
target firmware_ln882h (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IROM(0x00000000,0x00040000) IRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: firmware_XIP
  BeforeMake: python    ..\..\..\tools\python_scripts\sdk_env_check.py
  BeforeMake: python3 ..\..\..\tools\python_scripts\before_build_keil.py  -p  ..\cfg\flash_partition_cfg.json -o  ..\cfg\flash_partition_table.h
  AfterMake: python3  ..\..\..\tools\python_scripts\after_build_keil.py  -k firmware_XIP.uvprojx   -o flashimage.bin
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: LN882H, ARM_MATH_CM4
  c misc: --gnu
  c include: ..\..\..\components\net\lwip-2.1.3\src\include;..\..\..\components\net\lwip-2.1.3\src\port\ln_osal\include;..\cfg;..\bsp;..\app;..\..\..\components\fs\nvds;..\..\..\components\fs\partition_mgr;..\..\..\components\fs\kv\kv_port;..\..\..\components\fs\kv\kv;..\..\..\components\serial;..\..\..\components\net\dhcpd;..\..\..\components\net\iperf;..\..\..\components\net\ping;..\..\..\components\kernel;..\..\..\components\kernel\FreeRTOS\Source\include;..\..\..\components\kernel\FreeRTOS_Adapter;..\..\..\components\kernel\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\..\components;..\..\..\components\utils;..\..\..\components\utils\debug\runtime;..\..\..\components\utils\debug\reboot_trace;..\..\..\mcu\driver_ln882h;..\..\..\mcu\driver_ln882h\reg;..\..\..\mcu\CMSIS_5.3.0;..\..\..\mcu\ln882h;..\..\..\components\ln_at;..\..\..\components\ln_at\adapter;..\..\..\components\ln_at\cmd;..\..\..\components\ln_at\parser;..\..\..\components\ln_at\transfer;..\..\..\components\ln_at_cmd\system;..\..\..\components\wifi\wifi_lib_export;..\..\..\components\wifi\wifi_lib_import;..\..\..\components\wifi\wifi_manager;..\..\..\components\ble\modules\rwip\api;..\..\..\components\ble\ble_api\gap_gatt\api;..\..\..\components\ble\ble_lib_import;..\..\..\components\ble\mac\ble\hl\api;..\..\..\components\ble\mac\ble\hl\inc;..\..\..\components\ble\mac\ble\ll\api;..\..\..\components\ble\mac\ble\ll\import;..\..\..\components\ble\mac\ble\ll\src;..\..\..\components\ble\mac\ble\ll\src\llm;..\..\..\components\ble\mac\ble\profiles\netcfg\api;..\..\..\components\ble\mac\em\api;..\..\..\components\ble\mac\hci\api;..\..\..\components\ble\mac\sch\api;..\..\..\components\ble\modules\aes\api;..\..\..\components\ble\mac\sch\import;..\..\..\components\ble\modules\common\api;..\..\..\components\ble\modules\dbg\api;..\..\..\components\ble\modules\ecc_p256\api;..\..\..\components\ble\modules\h4tl\api;..\..\..\components\ble\modules\ke\api;..\..\..\components\ble\modules\lib_ver\api;..\..\..\components\ble\modules\nvds\api;..\..\..\components\ble\modules\rf\api;..\app\ble_usr_app;..\app\ble_usr_app\app_callback;..\..\..\components\ble\ble_profiles\prf_common;..\..\..\components\ble;..\..\..\components\ble\ble_arch;..\..\..\components\ble\ble_api\common;..\..\..\components\ble\app
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\cfg\ln882h.sct
  link misc: --keep=*.o(.no_init_data)
  group cpu
    ../startup/: startup_ln882h.S
    ../../../mcu/ln882h/: system_ln882h.c ln882h.h ln882h_rom_fun.h mem_map_ln882h.h base_addr_ln882h.h
  group ln882h_hal
    ../../../mcu/driver_ln882h/hal/: hal_cache.c hal_common.c hal_flash.c hal_qspi.c hal_uart.c hal_wdt.c hal_trng.c hal_gpio.c hal_interrupt.c hal_clock.c hal_misc.c hal_ext.c hal_timer.c hal_adc.c hal_efuse.c hal_rtc.c
  group bsp
    ../bsp/: serial_hw.c drv_adc_measure.c
  group util
    ../../../components/utils/debug/: ln_assert.c log.c
    ../../../components/utils/fifo/: fifobuf.c
    ../../../components/utils/: crc32.c ln_misc.c wrap_stdio.c system_parameter.c ln_psk_calc.c ln_sha1.c ln_aes.c
    ../../../components/utils/debug/CmBacktrace/: cm_backtrace.c
    ../../../components/utils/reboot_trace/: reboot_trace.c
    ../../../components/utils/runtime/: runtime.c
    ../../../components/utils/power_mgmt/: ln_pm.c
  group app
    ../app/: main.c usr_app.c mqtt_example.c mqtt_example.h mqtt_task.c mqtt_task.h
  group at_cmd
    ../../../components/ln_at/adapter/: ln_at_adapt.c
    ../../../components/ln_at/cmd/: ln_at_cmd.c ln_at_cmd_basic.c
    ../../../components/ln_at/parser/: ln_at_parser.c
    ../../../components/ln_at/transfer/: ln_at_transfer.c
    ../../../components/ln_at/: ln_at.c ln_at_server.c
    ../../../components/ln_at_cmd/system/: ln_at_cmd_system.c
    ../../../components/ln_at_cmd/wifi/: ln_at_cmd_wifi.c
    ../../../components/ln_at_cmd/net/: ln_at_cmd_net_test.c
  group FreeRTOS
    ../../../components/kernel/FreeRTOS/Source/: event_groups.c list.c queue.c tasks.c timers.c
    ../../../components/kernel/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../../components/kernel/FreeRTOS/: hooks.c
    ../../../components/kernel/FreeRTOS/Source/portable/MemMang/: heap_5.c
  group FreeRTOS_Adapter
    ../../../components/kernel/FreeRTOS_Adapter/: freertos_debug.c freertos_mutex.c freertos_queue.c freertos_semaphore.c freertos_thread.c freertos_timer.c freertos_common.c freertos_cpuusage.c
    ../../../components/kernel/osal/: osal.h
  group serial
    ../../../components/serial/: serial.c
  group lib
    ../../../lib/armcclib/: arm_cortexM4lf_math.lib ln882h_wifi.lib ln882h_ble_full_stack.lib
  group wifi_manager
    ../../../components/wifi/wifi_manager/: wifi_manager.c
    ../../../components/wifi/wifi_lib_import/: wifi_port.c wifi_port.h
    ../../../components/wifi/wifi_lib_export/: wifi.h
  group net
    ../../../components/net/ping/: ping.c
    ../../../components/net/dhcpd/: dhcp_packet.c dhcpd.c ip_allocator.c
    ../../../components/net/iperf/: iperf.c
  group fs
    ../../../components/fs/partition_mgr/: flash_partition_mgr.c
    ../../../components/fs/nvds/: ln_nvds.c
    ../../../components/fs/kv/kv/: ln_kv.c
    ../../../components/fs/kv/kv_port/: ln_kv_port.c
  group lwip213/core
    ../../../components/net/lwip-2.1.3/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../components/net/lwip-2.1.3/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../../../components/net/lwip-2.1.3/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group lwip213/api
    ../../../components/net/lwip-2.1.3/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../components/net/lwip-2.1.3/src/apps/sntp/: sntp.c
  group lwip213/netif
    ../../../components/net/lwip-2.1.3/src/netif/: ethernet.c
  group lwip213/port/ln_osal
    ../../../components/net/lwip-2.1.3/src/port/ln_osal/arch/: sys_arch.c
    ../../../components/net/lwip-2.1.3/src/port/ln_osal/netif/: ethernetif.c
    ../../../components/net/lwip-2.1.3/src/port/ln_osal/include/: lwipopts.h
  group lwip213/apps
    ../../../components/net/lwip-2.1.3/src/apps/mqtt/: mqtt.c
  group ble_lib_import
    ../../../components/ble/ble_lib_import/: ble_port.c ble_port.h
    ../../../components/ble/ble_arch/: ble_arch_main.c
  group ble_app
    ../app/ble_usr_app/: usr_ble_app.c usr_send_data.c
    ../app/ble_usr_app/app_callback/: ln_gap_callback.c ln_gatt_callback.c
  group ble_api
    ../../../components/ble/ble_api/gap_gatt/src/: ln_app_gap.c ln_app_gatt.c
  group ble_profile
    ../../../components/ble/ble_profiles/prf_common/: prf_ble.c prf_utils.c
