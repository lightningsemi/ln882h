# Keil uVision project firmware_XIP.uvprojx, settings and files
target firmware_ln882h (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IROM(0x00000000,0x00040000) IRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: firmware_XIP
  BeforeMake: python    ..\..\..\..\tools\python_scripts\sdk_env_check.py
  BeforeMake: python3 ..\..\..\..\tools\python_scripts\before_build_keil.py  -p  ..\cfg\flash_partition_cfg.json -o  ..\cfg\flash_partition_table.h
  AfterMake: python3  ..\..\..\..\tools\python_scripts\after_build_keil.py  -k  #P -s ../../../../ -o flashimage.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: LN882H, ARM_MATH_CM4, MBEDTLS_CONFIG_FILE=<mbedtls_config.h>
  c include: ..\..\..\..\components;..\..\..\..\components\wifi\wifi_mac\include;..\..\..\..\components\wifi\wifi_mac\Common;..\..\..\..\components\wifi\wifi_mac\Controller\AP;..\..\..\..\components\wifi\wifi_mac\Controller\AP-STA;..\..\..\..\components\wifi\wifi_mac\Controller\ModeIF;..\..\..\..\components\wifi\wifi_mac\Controller\STA;..\..\..\..\components\wifi\wifi_mac\Controller\STA\ProtIF;..\..\..\..\components\wifi\wifi_mac\Core\AP-STA;..\..\..\..\components\wifi\wifi_mac\Core\AP-STA\M802_11e;..\..\..\..\components\wifi\wifi_mac\Core\AP-STA\M802_11h;..\..\..\..\components\wifi\wifi_mac\Core\AP-STA\M802_11i;..\..\..\..\components\wifi\wifi_mac\Core\AP-STA\M802_11n;..\..\..\..\components\wifi\wifi_mac\Core\AP-STA\ProtIF;..\..\..\..\components\wifi\wifi_mac\Core\STA;..\..\..\..\components\wifi\wifi_mac\Core\STA\M802_11e;..\..\..\..\components\wifi\wifi_mac\Core\STA\M802_11h;..\..\..\..\components\wifi\wifi_mac\Core\STA\M802_11i;..\..\..\..\components\wifi\wifi_mac\Core\STA\M802_11n;..\..\..\..\components\wifi\wifi_mac\Core\STA\M802_1x;..\..\..\..\components\wifi\wifi_mac\Core\STA\ProtIF;..\..\..\..\components\wifi\wifi_mac\Core\AP;..\..\..\..\components\wifi\wifi_mac\Core\AP\M802_11e;..\..\..\..\components\wifi\wifi_mac\Core\AP\M802_11h;..\..\..\..\components\wifi\wifi_mac\Core\AP\M802_11i;..\..\..\..\components\wifi\wifi_mac\Core\AP\M802_11n;..\..\..\..\components\wifi\wifi_mac\Core\AP\M802_1x;..\..\..\..\components\wifi\wifi_mac\Core\AP\ProtIF;..\..\..\..\components\wifi\wifi_mac\Core\ModeIF;..\..\..\..\components\wifi\wifi_mac\Edge\Host;..\..\..\..\components\wifi\wifi_mac\Edge\IF;..\..\..\..\components\wifi\wifi_mac\Edge\MACHW;..\..\..\..\components\wifi\wifi_mac\Edge\RF\LN;..\..\..\..\components\wifi\wifi_mac\Edge\RF\GENERIC_RF;..\..\..\..\components\wifi\wifi_mac\Edge\PHY\PHYHW\LN;..\..\..\..\components\wifi\wifi_mac\Edge\PHY\PHYProt\P802_11n;..\..\..\..\components\wifi\wifi_mac\Utils\MM;..\..\..\..\components\wifi\wifi_mac\Utils\QM;..\..\..\..\components\wifi\wifi_mac\CSL;..\..\..\..\components\wifi\wifi_mac\Test\MacSwTest;..\..\..\..\components\wifi\wifi_mac\Edge\TEMP_CAL;..\..\..\..\components\wifi\wifi_mac\Edge\RF_HW;..\..\..\..\components\wifi\wifi_mac\Edge\RF_IMG_CAL\hw_img_cal;..\..\..\..\components\wifi\wifi_mac\Edge\RF_IMG_CAL\image_cal;..\..\..\..\components\wifi\wifi_cfg\include;..\..\..\..\components\wifi\wifi_if;..\..\..\..\components\wifi\wifi_lib_export;..\..\..\..\components\wifi\wifi_lib_import;..\..\..\..\components\wifi\wifi_manager;..\..\..\..\components\net\lwip-2.1.3\src\include;..\..\..\..\components\net\lwip-2.1.3\src\port\ln_osal\include;..\..\..\..\components\fs\nvds;..\..\..\..\components\fs\partition_mgr;..\..\..\..\components\fs\kv\kv_port;..\..\..\..\components\fs\kv\kv;..\..\..\..\components\serial;..\..\..\..\components\net\dhcpd;..\..\..\..\components\net\iperf;..\..\..\..\components\net\ping;..\..\..\..\components\kernel;..\..\..\..\components\kernel\FreeRTOS\Source\include;..\..\..\..\components\kernel\FreeRTOS_Adapter;..\..\..\..\components\kernel\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\..\..\components\utils;..\..\..\..\components\utils\debug\runtime;..\..\..\..\components\utils\debug\reboot_trace;..\..\..\..\components\ln_at;..\..\..\..\components\ln_at\adapter;..\..\..\..\components\ln_at\cmd;..\..\..\..\components\ln_at\parser;..\..\..\..\components\ln_at\transfer;..\..\..\..\components\ln_at_cmd\system;..\..\..\..\components\aws\aws-iot-device-sdk-embedded-C\libraries\standard\coreMQTT\source\include;..\..\..\..\components\aws\aws-iot-device-sdk-embedded-C\libraries\standard\coreMQTT\source\interface;..\..\..\..\components\aws\aws-iot-device-sdk-embedded-C\libraries\standard\backoffAlgorithm\source\include;..\..\..\..\components\aws\aws_port\logging-stack;..\..\..\..\components\aws\aws_port\transport;..\..\..\..\components\aws\aws_port\posix_compat;..\..\..\..\components\net\mbedtls\port_ln\include;..\..\..\..\components\net\mbedtls\include;..\..\..\..\mcu\driver_ln882h;..\..\..\..\mcu\driver_ln882h\reg;..\..\..\..\mcu\CMSIS_5.3.0;..\..\..\..\mcu\ln882h;..\..\certificates;..\..\bsp;..\..\app;..\cfg;..\http_mutual_auth;..\..\..\..\components\aws\aws-iot-device-sdk-embedded-C\libraries\standard\coreHTTP\source\include;..\..\..\..\components\aws\aws-iot-device-sdk-embedded-C\libraries\standard\coreHTTP\source\dependency\3rdparty\llhttp\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\cfg\ln882h.sct
  link misc: --keep=*.o(.no_init_data)
  group cpu
    ../../startup/: startup_ln882h.S
    ../../../../mcu/ln882h/: system_ln882h.c ln882h.h ln882h_rom_fun.h mem_map_ln882h.h base_addr_ln882h.h
  group ln882h_hal
    ../../../../mcu/driver_ln882h/hal/: hal_cache.c hal_common.c hal_flash.c hal_qspi.c hal_uart.c hal_wdt.c hal_trng.c hal_gpio.c hal_interrupt.c hal_clock.c hal_misc.c hal_ext.c hal_timer.c hal_adc.c hal_efuse.c
  group bsp
    ../../bsp/: serial_hw.c drv_adc_measure.c
  group util
    ../../../../components/utils/debug/: ln_assert.c log.c
    ../../../../components/utils/fifo/: fifobuf.c
    ../../../../components/utils/: crc32.c ln_misc.c wrap_stdio.c system_parameter.c ln_psk_calc.c ln_sha1.c ln_aes.c
    ../../../../components/utils/debug/CmBacktrace/: cm_backtrace.c
    ../../../../components/utils/reboot_trace/: reboot_trace.c
    ../../../../components/utils/runtime/: runtime.c
    ../../../../components/utils/power_mgmt/: ln_pm.c
  group app
    ../../app/: main.c usr_app.c
  group at_cmd
    ../../../../components/ln_at/adapter/: ln_at_adapt.c
    ../../../../components/ln_at/cmd/: ln_at_cmd.c ln_at_cmd_basic.c
    ../../../../components/ln_at/parser/: ln_at_parser.c
    ../../../../components/ln_at/transfer/: ln_at_transfer.c
    ../../../../components/ln_at/: ln_at.c ln_at_server.c
    ../../../../components/ln_at_cmd/system/: ln_at_cmd_system.c
    ../../../../components/ln_at_cmd/wifi/: ln_at_cmd_wifi.c
    ../../../../components/ln_at_cmd/net/: ln_at_cmd_net_test.c
  group FreeRTOS
    ../../../../components/kernel/FreeRTOS/Source/: event_groups.c list.c queue.c tasks.c timers.c
    ../../../../components/kernel/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../../../components/kernel/FreeRTOS/: hooks.c
    ../../../../components/kernel/FreeRTOS/Source/portable/MemMang/: heap_5.c
  group FreeRTOS_Adapter
    ../../../../components/kernel/FreeRTOS_Adapter/: freertos_debug.c freertos_mutex.c freertos_queue.c freertos_semaphore.c freertos_thread.c freertos_timer.c freertos_common.c freertos_cpuusage.c
    ../../../../components/kernel/osal/: osal.h
  group serial
    ../../../../components/serial/: serial.c
  group lib
    ../../../../lib/armcclib/: arm_cortexM4lf_math.lib ln882h_wifi.lib
  group wifi_manager
    ../../../../components/wifi/wifi_manager/: wifi_manager.c
    ../../../../components/wifi/wifi_lib_import/: wifi_port.c wifi_port.h ln_wifi_err.h
    ../../../../components/wifi/wifi_lib_export/: wifi.h
  group net
    ../../../../components/net/ping/: ping.c
    ../../../../components/net/dhcpd/: dhcp_packet.c dhcpd.c ip_allocator.c
    ../../../../components/net/iperf/: iperf.c
  group fs
    ../../../../components/fs/partition_mgr/: flash_partition_mgr.c
    ../../../../components/fs/nvds/: ln_nvds.c
    ../../../../components/fs/kv/kv/: ln_kv.c
    ../../../../components/fs/kv/kv_port/: ln_kv_port.c
  group lwip213/core
    ../../../../components/net/lwip-2.1.3/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../../components/net/lwip-2.1.3/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../../../../components/net/lwip-2.1.3/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group lwip213/api
    ../../../../components/net/lwip-2.1.3/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip213/netif
    ../../../../components/net/lwip-2.1.3/src/netif/: ethernet.c
  group lwip213/port/ln_osal
    ../../../../components/net/lwip-2.1.3/src/port/ln_osal/arch/: sys_arch.c
    ../../../../components/net/lwip-2.1.3/src/port/ln_osal/netif/: ethernetif.c
    ../../../../components/net/lwip-2.1.3/src/port/ln_osal/include/: lwipopts.h
  group aws/port
    ../../../../components/aws/aws_port/posix_compat/: clock_freertos.c
    ../../../../components/aws/aws_port/transport/: network_transport.c
  group aws/coreHTTP
    ../../../../components/aws/aws-iot-device-sdk-embedded-C/libraries/standard/coreHTTP/source/: core_http_client.c
    ../../../../components/aws/aws-iot-device-sdk-embedded-C/libraries/standard/coreHTTP/source/dependency/3rdparty/llhttp/src/: api.c http.c llhttp.c
  group aws/backoffAlgorithm
    ../../../../components/aws/aws-iot-device-sdk-embedded-C/libraries/standard/backoffAlgorithm/source/: backoff_algorithm.c
  group aws/demo
    ../../certificates/: ca_cert_def.c
    ../http_mutual_auth/: http_demo_mutual_auth.c http_demo_url_utils.c http_demo_utils.c
  group mbedtls
    ../../../../components/net/mbedtls/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md_wrap.c md2.c md4.c md5.c memory_buffer_alloc.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs11.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group mbedtls_wrapper
    ../../../../components/net/mbedtls/port_ln/library/: net_sockets.c platform.c threading_alt.c timing.c
